# Keil uVision project ZKSTM.uvproj, settings and files
target LED_HUAIBEI (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED_HUAIBEI +hex
  c flags: Optim=1 OneElfS=1
  c misc: --preinclude=led_huaibei.h
  c include: FreeRTOS/include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\Libraries\CMSIS\CM3\CoreSupport;.\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\SRC;.\ZKLibs;.\ZKLibs\M35;.\ZKLibs\stm32;.\Led;.\Preincludes
  asm include: FreeRTOS/include
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Libraries_CMSIS_CM3_CoreSupport
    ./Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group Libraries_CMSIS_CM3_DeviceSupport_ST_STM32F10x
    ./Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries_STM32F10x_StdPeriph_Driver_src
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
  group FreeRTOS_portable_MemMang
    ./FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS_portable_RVDS_ARM_CM3
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group SRC
    ./SRC/: FreeRTOSConfig.c gsm.c main.c protocol.c startup_stm32f10x_hd_arm.s tim.c xfs.c debug_handler.c
    ./src/: recovery.c sms_cmd.c version.c
  group ZKLibs
    ./ZKLibs/: atcmd.c sms.c ringbuffer.c second_datetime.c
  group ZKLibs_stm32
    ./ZKLibs/stm32/: font_dot_array.c fsmc_nor.c rtc.c libupdater.c norflash.c uart_debug.c watchdog.c unicode2gbk.c
  group LED
    ./Led/: display.c led_lowlevel.c sht1x.c seven_seg_led.c test.c softpwm_led.c
  group SPEAKER
    ./Speaker/: mp3.c soundcontrol.c
